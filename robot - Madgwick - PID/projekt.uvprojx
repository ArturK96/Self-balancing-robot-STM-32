# Keil uVision project projekt.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projekt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c MadgwickAHRS.c
software components: CMSIS:CORE 5.2.0, Device:STM32Cube HAL:COMMON 1.9.0, Device:STM32Cube HAL:CORTEX 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:FLASH 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:STM32Cube HAL:USART 1.9.0, Device:Startup 1.0.0
